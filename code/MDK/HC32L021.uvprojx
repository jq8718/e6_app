# Keil uVision project HC32L021.uvprojx, settings and files
target HC32L021_Release (6100001::V6.10.1::.\ARMCLANG)
  device: HC32L021C8PB HDSC
  pack: HDSC.HC32L02x.1.1.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HC32L021 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L?
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __DEBUG
  c include: ../source;../../common;../../driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x2000 size 0xde00
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --keep=*Handler
  group common
    ../../common/: system_hc32l021.c board_stkhc32l021.c interrupts_hc32l021.c boot_param.c
    ./: startup_hc32l021.s
  group source
    ../source/: main.c i2c_iap_app.c
  group driver
    ../../driver/src/: sysctrl.c gpio.c btim.c ddl.c hsi2c.c lpuart.c
software components: CMSIS:CORE 6.1.0
